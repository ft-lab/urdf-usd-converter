Commit message: URDF 1.1: Supports capsule and quat_xyzw

File: tests/data/verifying_elements.urdf (robot description, URDF)
Before this commit: robot verifying_elements, 4 links, 3 joints
Links:
- link link4: geometry visual capsule length=1 radius=0.5
